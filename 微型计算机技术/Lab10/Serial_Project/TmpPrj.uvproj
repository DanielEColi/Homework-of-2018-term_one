# Keil uVision project TmpPrj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: TmpPrj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\TmpCode
  group Source Group 1
    ../TmpCode/: main.c Uart.c ADC.c
