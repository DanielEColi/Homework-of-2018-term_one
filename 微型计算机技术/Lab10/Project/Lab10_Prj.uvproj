# Keil uVision project Lab10_Prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Lab10_Prj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Code
  group Source Group 1
    ../Code/: ADC.c main.c Seg8LED_Disp.c Uart.c
